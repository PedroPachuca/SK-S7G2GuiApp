# IAR project proj_guxi_hello_world.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FS7G27H Renesas R7FS7G27H
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: src; src/synergy_gen; synergy/ssp/inc; synergy/ssp/inc/bsp; synergy/ssp/inc/bsp/cmsis/Include; synergy/ssp/inc/driver/api; synergy/ssp/inc/driver/instances; synergy/ssp/inc/framework/api; synergy/ssp/inc/framework/el; synergy/ssp/inc/framework/instances; synergy/ssp/inc/framework/tes; synergy/ssp/src/framework/el/tx; synergy_cfg/ssp_cfg/bsp; synergy_cfg/ssp_cfg/driver; synergy_cfg/ssp_cfg/framework; synergy_cfg/ssp_cfg/framework/el; synergy_cfg/ssp_cfg/framework/tes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: proj_guxi_hello_world.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
